SUMMARY = "Enable nad update sshd service"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SYSTEMD_AUTO_ENABLE = "enable"
